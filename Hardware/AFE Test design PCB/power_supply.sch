File: Hardware/AFE Test design PCB/power_supply.sch (KiCad schematic (older format))
At the start: 24 parts

Commit message: update
Parts:
- gave numbers to parts that had none: 24
