File: Hardware/AFE Test design PCB/Onderzoek_Malerini.sch (KiCad schematic (older format))
At the start: 36 parts

Commit message: update
Parts:
- gave numbers to parts that had none: 36
