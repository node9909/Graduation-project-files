File: Hardware/AFE Test design PCB/OriginalDesing1.sch (KiCad schematic (older format))
At the start: 33 parts

Commit message: update
Parts:
- gave numbers to parts that had none: 33
