File: Hardware/AFE Test design PCB/Alternativedesing1.sch (KiCad schematic (older format))
At the start: 24 parts

Commit message: update
Parts:
- gave numbers to parts that had none: 24
