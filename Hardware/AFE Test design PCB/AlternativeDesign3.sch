File: Hardware/AFE Test design PCB/AlternativeDesign3.sch (KiCad schematic (older format))
At the start: 39 parts

Commit message: update
Parts:
- gave numbers to parts that had none: 39
